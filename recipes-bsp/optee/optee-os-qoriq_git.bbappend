
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

OPTEEMACHINE = "ls1043ardb"

COMPATIBLE_MACHINE = "(ls1043ardb|ls1046ardb|ls1012ardb|ls1043avnpevb)"


