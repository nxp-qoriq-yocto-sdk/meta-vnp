
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE = "(ls1043a|ls1046a|ls1012a|ls1043avnpevb)"

