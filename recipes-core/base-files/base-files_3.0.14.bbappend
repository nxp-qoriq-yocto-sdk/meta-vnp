FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

hostname_ls1043avnpevb = "MPC-LS-VNP-EVB"
hostname_ls1043avnprdb = "MPC-LS-VNP-RDB"
