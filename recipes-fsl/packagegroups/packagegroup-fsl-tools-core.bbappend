
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


RDEPENDS_${PN}_append_ls1043avnpevb = " \
    dpdk \
"
